# Keil uVision project masslink.uvprojx, settings and files
target masslinkV1.0.0 (5060528::V5.06 update 5 (build 528)::ARMCC)
  device: STM32F103C8 STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.3.0
  cpu: IRAM(0x20000000,0x00005000) IROM(0x08000000,0x00010000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: masslink +hex
  c flags: Optim=1 OneElfS=1 uC99=1 wLevel=2
  c define: STM32F103C8,STM32F10X_MD,
  c include: ..\procode\gos;..\procode\user;..\procode\bsp;.\RTE;..\procode\mid
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x5000
  scatter file: ..\config\masslinkV001.sct
  group gos
    ../procode/gos/: glist.c gtimer.c gpipe.c retarget.c gevent.c gutility.c
  group user
    ../procode/user/: gboot.c system_stm32f10x.c gmain.c girq.s stm32f10x_it.c gFreezeUsertask.c
  group bsp
    ../procode/bsp/: gusart.c gbsp.c gadc.c gtimer.c
  group mid
    ../procode/mid/: cJSON.c glcd.c
target ISO_MassLink (5060422::V5.06 update 4 (build 422)::ARMCC)
  device: STM32F103ZE STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.3.0
  cpu: IRAM(0x20000000,0x10000) IROM(0x08000000,0x80000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: masslink +hex
  c flags: Optim=1 OneElfS=1 uC99=1 wLevel=2
  c define: STM32F103RC,STM32F10X_HD,
  c include: as above
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x10000
  scatter file: ..\config\masslinkV001.sct
software components: CMSIS:CORE 5.1.2, Device:StdPeriph Drivers:ADC 3.5.0, Device:StdPeriph Drivers:DMA 3.5.0, Device:StdPeriph Drivers:EXTI 3.5.0, Device:StdPeriph Drivers:Flash 3.5.0, Device:StdPeriph Drivers:Framework 3.5.1, Device:StdPeriph Drivers:GPIO 3.5.0, Device:StdPeriph Drivers:RCC 3.5.0, Device:StdPeriph Drivers:TIM 3.5.0, Device:StdPeriph Drivers:USART 3.5.0
